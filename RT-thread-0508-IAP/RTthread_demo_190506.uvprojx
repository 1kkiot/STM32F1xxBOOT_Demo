# Keil uVision project RTthread_demo_190506.uvprojx, settings and files
target RTT_Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTthread_demo_190506 +hex
  AfterMake: fromelf --bin !L --output Boot.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: .\App;.\Base;.\Config;.\Core;.\HAL\STM32F1xx_HAL_Driver\Inc;.\HAL\STM32F1xx_HAL_Driver\Inc\Legacy;.\User;.\Sys;.\BOOT;.\Ymodem
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: startup_stm32f103xe.s
  group Core
    ./Core/: cmsis_armcc.h core_cm3.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f1xx.h stm32f103xe.h system_stm32f1xx.c system_stm32f1xx.h
  group base
    ./Base/: arm_base_define.h
  group Config
    ./Config/: stm32f1xx_hal_conf.h
  group HAL
    ./HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_usart.c
  group Sys
    ./Sys/: Sys.c Sys.h SysGpio.c SysGpio.h uart.c uart.h
  group BOOT
    ./BOOT/: boot1.c boot1.h flash.c flash.h
  group Ymodem
    ./Ymodem/: common.c common.h flash_if.c flash_if.h main.h menu.c menu.h ymodem.c ymodem.h
  group User
    ./User/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c stm32f1xx_it.h
  group ReadME
    ./ReadME/: ReadME.txt
