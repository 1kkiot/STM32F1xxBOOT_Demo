# Keil uVision project ZET6-HAL.uvprojx, settings and files
target ZET6-HAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ZET6-HAL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: .\App;.\Croe;.\HAL_Drive\STM32F1xx_HAL_Driver\Inc;.\HAL_Drive\STM32F1xx_HAL_Driver\Inc\Legacy;.\User;.\Sys;.\Custom;.\App
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./HAL_Drive/: startup_stm32f103xe.s
  group Custom
    ./Custom/: base.h
  group Croe
    ./Croe/: cmsis_armcc.h core_cm3.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f1xx.h stm32f103xe.h system_stm32f1xx.c system_stm32f1xx.h
  group HAL_Config
    ./HAL_Drive/: stm32f1xx_hal_conf.h
  group HAL_Drive
    ./HAL_Drive/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
  group Sys
    ./Sys/: Sys.c Sys.h gpio.c gpio.h uart.c uart.h
  group User
    ./User/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c stm32f1xx_it.h
  group App
    ./App/: queue.c queue.h adc.c adc.h Ranging.c Ranging.h flash.c flash.h updata.c updata.h
  group ReadMe
    ./ReadMe/: ReadMe.txt
